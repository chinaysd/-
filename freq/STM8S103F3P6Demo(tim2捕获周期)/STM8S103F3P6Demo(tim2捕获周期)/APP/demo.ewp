# IAR project demo.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: TEST
  ICCSTM8.CCIncludePath2: ; APP; Hal; STM8s; STM8S_Driver\inc; STM8S_Driver\src
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: demo.s19
  ILINK.IlinkOutputFile: demo.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group APP
    ./: Bsp.c Bsp.h Includes.h main.c
  group Hal
    ../Hal/: hal_led.c Hal_tim2.c Hal_tim2.h Hal_uart1.c Hal_uart1.h
  group STM8s
    ../STM8S_Driver/inc/: stm8s.h
    ../STM8s/: stm8s_conf.h stm8s_it.c stm8s_it.h
  group STM8S_Driver
    ../STM8S_Driver/src/: stm8s_clk.c stm8s_gpio.c stm8s_tim2.c stm8s_uart1.c
