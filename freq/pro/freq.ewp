# IAR project freq.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S103; USE_STDPERIPH_DRIVER
  ICCSTM8.CCIncludePath2: C:\Users\Administrator\Desktop\freq\bsp; C:\Users\Administrator\Desktop\freq\lib\inc; C:\Users\Administrator\Desktop\freq\TimeOut; C:\Users\Administrator\Desktop\freq\user
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: freq.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group bsp
    ../bsp/: bsp_test.c bsp_uart1.c
    ../user/: bsp_timer.c
  group lib
    ../lib/src/: stm8s_clk.c stm8s_gpio.c stm8s_iwdg.c stm8s_tim2.c stm8s_uart1.c
  group user
    ../user/: main.c stm8s_it.c system.c
